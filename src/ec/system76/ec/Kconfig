## src/ec/system76/ec/Kconfig
```kconfig
config EC_SYSTEM76_EC
	bool
	help
	  System76 EC

config EC_SYSTEM76_EC_COLOR_KEYBOARD
	bool
    default n
```
